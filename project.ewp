# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; STM32F103xE; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; packages\ota_downloader-latest; ..\..\..\components\drivers\include; ..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include; ..\libraries\STM32F1xx_HAL\CMSIS\Include; ..\..\..\components\libc\compilers\common\extension; ..\libraries\HAL_Drivers\drv_flash; ..\..\..\components\libc\compilers\common; board\CubeMX_Config\Inc; packages\fal-v1.0.0\inc; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\stdio; ..\..\..\components\fal\inc; board\porting; .; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\drivers\spi; ..\libraries\HAL_Drivers; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\cortex-m3; ..\..\..\libcpu\arm\common; ..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc; ..\..\..\components\drivers\spi\sfud\inc; ..\..\..\components\utilities\ymodem
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c pulse_encoder.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_adc.c drv_can.c drv_common.c drv_gpio.c drv_pulse_encoder.c drv_pwm.c drv_spi.c drv_usart.c drv_wdt.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f1.c
  group fal
    packages/fal-v1.0.0/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
    packages/fal-v1.0.0/samples/porting/: fal_flash_sfud_port.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_tim.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_wwdg.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group ota_downloader
    packages/ota_downloader-latest/src/: ymodem_ota.c
  group Utilities
    ../../../components/utilities/ymodem/: ymodem.c
